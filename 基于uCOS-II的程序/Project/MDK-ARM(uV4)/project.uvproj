# Keil uVision project project.uvproj, settings and files
target QTU-06-uCOSII (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\uCOS-II\uCOS-II\Source;..\..\uCOS-II\uC-LIB;..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-II\uC-CPU;..\..\uCOS-II\uC-CPU\ARM-Cortex-M3\RealView;..\..\User;..\..\Libraries\CMSIS\Include;..\..\User\fatfs;..\..\User\fatfs\option;..\..\User\gps\nmea_decode;..\..\User\gps\nmea_decode\include\nmea;..\..\User\gps\nmea_decode\include;..\..\User\gps;..\..\User\myfile
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: app.c cpu_bsp.c app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h nvic.c includes.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: adc.c anbt_dmp_driver.c anbt_dmp_mpu6050.c anbt_i2c.c bsp_pwm_output.c bsp_spi_nrf.c can.c ds1302.c led.c stmflash.c TIM_Capture.c usart.c wdg.c
    ../../User/bsp/inc/: adc.h anbt_dmp_driver.h anbt_dmp_fun.h anbt_dmp_mpu6050.h anbt_i2c.h bsp_pwm_output.h bsp_spi_nrf.h can.h ds1302.h led.h nvic.h stmflash.h TIM_Capture.h usart.h wdg.h
  group MyFile
    ../../User/myfile/: DataCal.c datatransfer.c MyMath.c DataCal.h datatransfer.h MyMath.h
  group FatFS
    ../../User/fatfs/: bsp_sdio_sd.c diskio.c ff.c ff_user.c bsp_sdio_sd.h diskio.h ff.h ff_user.h ffconf.h integer.h
  group GPS
    ../../User/gps/: gps_config.c nema_decode_test.c gps_config.h
    ../../User/gps/nmea_decode/include/nmea/: config.h context.h generate.h generator.h gmath.h info.h nmea.h parse.h parser.h sentence.h time.h tok.h units.h
    ../../User/gps/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
