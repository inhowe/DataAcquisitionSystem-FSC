# Keil uVision project iSO-STM32.uvproj, settings and files
target QTU-06 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: QTU-06 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\USART;..\..\User\12864;..\..\User\ADC;..\..\User\CAPTURE;..\..\User\EXTI;..\..\User\KEY;..\..\User\NVIC;..\..\User\PWM;..\..\User\SysTick;..\..\User\NRF;..\..\User\WDG;..\..\User\MPU6050;..\..\User\fatfs;..\..\User\fatfs\option;..\..\User\gps\nmea_decode\include;..\..\User\gps;..\..\User\gps\nmea_decode\include\nmea
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group APP
    ../../User/NVIC/: nvic.c nvic.h
    ../../User/WDG/: wdg.c wdg.h
    ../../User/USART/: usart.c usart.h
    ../../User/NRF/: bsp_spi_nrf.c bsp_spi_nrf.h
    ../../User/SysTick/: bsp_SysTick.c bsp_SysTick.h
    ../../User/ADC/: adc.c adc.h
    ../../User/PWM/: bsp_pwm_output.c bsp_pwm_output.h
    ../../User/CAPTURE/: TIM_Capture.c TIM_Capture.h
    ../../User/: can.c can.h ds1302.c ds1302.h stmflash.c stmflash.h CD4067.c CD4067.h
  group USER
    ../../User/: MyMath.c MyMath.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h includes.h includes.c datatransfer.c datatransfer.h DataCal.c DataCal.h led.c led.h
    ../../User/KEY/: key.c key.h
  group DMP
    ../../User/MPU6050/: anbt_dmp_driver.c anbt_dmp_driver.h anbt_dmp_fun.h anbt_dmp_mpu6050.c anbt_dmp_mpu6050.h anbt_i2c.c anbt_i2c.h
  group FatFS
    ../../User/fatfs/: bsp_sdio_sd.c diskio.c ff.c ff_user.c ff_user.h
  group GPS
    ../../User/gps/: gps_config.c nema_decode_test.c
    ../../User/gps/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
